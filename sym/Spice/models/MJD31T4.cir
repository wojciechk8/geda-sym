**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*    Modeling services provided by   *
* Interface Technologies www.i-t.com *
**************************************
.MODEL mjd31t4 npn
+IS=6.95027e-11 BF=105.56 NF=1.36741 VAF=29.3386
+IKF=5.83898 ISE=7.74849e-12 NE=3.34401 BR=3.72969
+NR=1.26998 VAR=3.14723 IKR=3.54265 ISC=4.75e-13
+NC=3.96875 RB=2.02686 IRB=0.0382523 RBM=0.0971173
+RE=0.00064053 RC=0.0901968 XTB=0.117997 XTI=1.03127
+EG=1.11257 CJE=3.08078e-10 VJE=0.930053 MJE=0.647829
+TF=1e-08 XTF=2.9992 VTF=3.61865 ITF=0.001
+CJC=3.02285e-10 VJC=0.888984 MJC=0.49062 XCJC=0.8031
+FC=0.8 CJS=0 VJS=0.75 MJS=0.5
+TR=1e-07 PTF=0 KF=0 AF=1
* Model generated on Dec 17, 2003
* Model format: SPICE3
