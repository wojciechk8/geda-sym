.SUBCKT mun5314dw1t1g 1 2 3 4 5 6
*Model generated on 10/29/2014
*MODEL FORMAT: SPICE3
*
x1 6 2 1 mun5314npn
x2 3 5 4 mun5314pnp
.ENDS mun5314dw1t1g
*
.SUBCKT mun5314npn 1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* BRT macro model
* External node
* Node 1 -> BRT_C
* Node 2 -> BRT_B
* Node 3 -> BRT_E
QOUT 1 4 3 qmodel
R1   2 4 10000
R2   4 3 47600
.MODEL qmodel npn
+IS=9.05733e-14 BF=328.908 NF=1.23385 VAF=88.6423
+IKF=0.113878 ISE=9.5934e-13 NE=2.08654 BR=1.2589
+NR=1.32681 VAR=101.436 IKR=0.112162 ISC=1.22304e-13
+NC=1.62367 RB=10.0022 IRB=0.2 RBM=10
+RE=0.0866541 RC=1.36722 XTB=1.81245 XTI=2.92602 EG=1.07571
+CJE=1.00004e-11 VJE=0.75 MJE=0.33 TF=1e-09
+XTF=1 VTF=10 ITF=0.01 CJC=3.45287e-12
+VJC=0.4 MJC=0.24743 XCJC=0.9 FC=0.5
.ENDS
*
.SUBCKT mun5314pnp 1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* BRT macro model
* External node
* Node 1 -> BRT_C
* Node 2 -> BRT_B
* Node 3 -> BRT_E
QOUT 1 4 3 qmodel
R1   2 4 10000
R2   4 3 47600
.MODEL qmodel pnp
+IS=9.26814e-14 BF=336.651 NF=1.004 VAF=123.784
+IKF=0.17852 ISE=9.62637e-13 NE=1.49796 BR=0.800188
+NR=1.07066 VAR=157.718 IKR=0.110979 ISC=9.99869e-14
+NC=2.00745 RB=10.5714 IRB=0.205636 RBM=10.5636
+RE=0.0252752 RC=1.53667 XTB=1.049 XTI=3.02477 EG=1.05
+CJE=1.00005e-11 VJE=0.75 MJE=0.33 TF=1e-09
+XTF=1 VTF=10 ITF=0.01 CJC=1.25363e-11
+VJC=0.4 MJC=0.615205 XCJC=0.9 FC=0.5
.ENDS
